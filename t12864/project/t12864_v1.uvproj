# Keil uVision project t12864_v1.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5804 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF5) CLOCK(32000000) DPC
  output: t12864_v1 +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\c;..\h
  group c
    ../c/: main.c system.c lcd.c key.c
  group h
    ../h/: system.h lcd.h key.h
    ../../../BACKUP/HEAD/sonix/: OPTIONS_SN8F5804.A51
