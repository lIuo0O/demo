# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5702 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: ADC +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source;.\Source
  group Source Group 1
    ./Source/: Main.c ADC.c
    ./: STARTUP.A51 OPTIONS_SN8F5702.A51
