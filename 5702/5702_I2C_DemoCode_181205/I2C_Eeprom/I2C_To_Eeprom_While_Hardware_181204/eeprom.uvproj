# Keil uVision project eeprom.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5702 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: i2c_master +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  group Lib
    ./: STARTUP.A51 OPTIONS_SN8F5702.A51
  group Src
    ./Src/: main.c i2c_master.c eeprom.c
