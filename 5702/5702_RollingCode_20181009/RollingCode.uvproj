# Keil uVision project RollingCode.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5702 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: RollingCode +hex
  AfterMake: HexConvert.exe $D "#H" FRC
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Src
  group Source Group 1
    ./: OPTIONS_SN8F5702.A51 STARTUP.A51
    ./Src/: Main.c
