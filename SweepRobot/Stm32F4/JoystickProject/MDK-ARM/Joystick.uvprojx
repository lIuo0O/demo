# Keil uVision project Joystick.uvprojx, settings and files
target Joystick (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Joystick +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM
  c misc: --locale=english
  c include: ..\Inc;..\..\RobotProject\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\RobotProject\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\RobotProject\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\RobotProject\Drivers\CMSIS\Include;..\..\RobotProject\Robot\RocRobotDriver\RocError;..\..\RobotProject\Robot\RocRobotDriver\RocLog;..\..\RobotProject\Robot\RocRobotDriver\RocLed;..\..\RobotProject\Robot\RocRobotDriver\RocOled;..\..\RobotProject\Robot\RocRobotDriver\RocBeeper;..\..\RobotProject\Robot\RocRobotDriver\RocBattery;..\..\RobotProject\Robot\RocRobotDriver\RocRemoteControl;..\..\RobotProject\Robot\RocRobotDriver\RocGui;..\..\RobotProject\Robot\RocRobotDriver\RocKey;..\..\RobotProject\Robot\RocRobotDriver\RocLoRa;..\Joystick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
    ../../RobotProject/Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../../RobotProject/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group Drivers/BSP
    ../../RobotProject/Robot/RocRobotDriver/RocBattery/: RocBattery.c
    ../../RobotProject/Robot/RocRobotDriver/RocBeeper/: RocBeeper.c
    ../../RobotProject/Robot/RocRobotDriver/RocGui/: RocFont.c
    ../../RobotProject/Robot/RocRobotDriver/RocKey/: RocKey.c
    ../../RobotProject/Robot/RocRobotDriver/RocLed/: RocLed.c
    ../../RobotProject/Robot/RocRobotDriver/RocLog/: RocLog.c
    ../../RobotProject/Robot/RocRobotDriver/RocOled/: RocOled.c
    ../../RobotProject/Robot/RocRobotDriver/RocRemoteControl/: RocRemoteControl.c
  group Drivers/LoRa
    ../../RobotProject/Robot/RocRobotDriver/RocLoRa/: eml3047.c lora_ptp.c sx1276.c utilities.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c
  group Application/Joystick
    ../Joystick/: RocJoystick.c
software components: CMSIS:CORE 5.0.0
